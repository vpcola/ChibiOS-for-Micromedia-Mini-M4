# Keil uVision project ch.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F415RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ch
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\;..\..\..\os\kernel\include;..\..\..\os\ports\common\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32F4xx;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32F4xx;..\..\..\os\hal\platforms\STM32;..\..\..\os\hal\platforms\STM32\GPIOv2;..\..\..\os\hal\platforms\STM32\I2Cv1;..\..\..\os\hal\platforms\STM32\OTGv1;..\..\..\os\hal\platforms\STM32\RTCv2;..\..\..\os\hal\platforms\STM32\SPIv1;..\..\..\os\hal\platforms\STM32\TIMv1;..\..\..\os\hal\platforms\STM32\USARTv1;..\..\..\os\various;..\..\..\test;..\boards\MIKROE_MINI_M4;..\..\..\os\various\cpp_wrappers;..\..\..\os\various\fatfs_bindings;..\..\..\ext\fatfs\src;..\..\..\ext\fatfs\src\option;..\ugfx;..\ugfx\src\gdisp;..\ugfx\src\gdisp\mcufont;..\ugfx\drivers\gdisp\ILI9341
  asm misc: --cpreproc
  asm include: ..\;..\..\..\boards\OLIMEX_STM32_P107;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group board
    ../boards/MIKROE_MINI_M4/: board.c
  group port
    ../../../os/ports/RVCT/ARMCMx/STM32F4xx/: vectors.s
    ../../../os/ports/RVCT/ARMCMx/: chcore.c chcore_v7m.c cstartup.s
    ../../../os/ports/common/ARMCMx/: nvic.c
  group kernel
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group hal
    ../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c tm.c uart.c usb.c
  group platform
    ../../../os/hal/platforms/STM32F4xx/: adc_lld.c ext_lld_isr.c hal_lld.c stm32_dma.c
    ../../../os/hal/platforms/STM32/: can_lld.c ext_lld.c mac_lld.c sdc_lld.c
    ../../../os/hal/platforms/STM32/GPIOv2/: pal_lld.c
    ../../../os/hal/platforms/STM32/I2Cv1/: i2c_lld.c
    ../../../os/hal/platforms/STM32/OTGv1/: usb_lld.c
    ../../../os/hal/platforms/STM32/RTCv2/: rtc_lld.c
    ../../../os/hal/platforms/STM32/SPIv1/: spi_lld.c
    ../../../os/hal/platforms/STM32/TIMv1/: gpt_lld.c icu_lld.c pwm_lld.c
    ../../../os/hal/platforms/STM32/USARTv1/: serial_lld.c uart_lld.c
  group test
    ../../../test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c
  group demo
    ../: chconf.h halconf.h mcuconf.h main.cpp
  group cpp_wrappers
    ../../../os/various/cpp_wrappers/: ch.cpp
  group fatfs_bindings
    ../../../os/various/fatfs_bindings/: fatfs_diskio.c fatfs_syscall.c
    ../../../ext/fatfs/src/: ff.c
    ../../../ext/fatfs/src/option/: unicode.c
  group ugfx
    ../ugfx/src/: gfx.c
    ../ugfx/src/gos/: gos_chibios.c gos_ecos.c gos_freertos.c gos_linux.c gos_osx.c gos_raw32.c gos_rawrtos.c gos_win32.c
    ../ugfx/src/gdriver/: gdriver_gdriver.c
    ../ugfx/src/gqueue/: gqueue_gqueue.c
    ../ugfx/src/gdisp/: gdisp_fonts.c gdisp_gdisp.c gdisp_image.c gdisp_image_bmp.c gdisp_image_gif.c gdisp_image_jpg.c gdisp_image_native.c gdisp_image_png.c
    ../ugfx/src/gdisp/mcufont/: mf_bwfont.c mf_encoding.c mf_font.c mf_justify.c mf_kerning.c mf_rlefont.c mf_scaledfont.c mf_wordwrap.c
    ../ugfx/src/gevent/: gevent_gevent.c
    ../ugfx/src/gtimer/: gtimer_gtimer.c
    ../ugfx/src/gwin/: gwin_button.c gwin_checkbox.c gwin_console.c gwin_container.c gwin_frame.c gwin_gl3d.c gwin_graph.c gwin_gwin.c gwin_image.c gwin_label.c gwin_list.c gwin_progressbar.c gwin_radio.c gwin_slider.c gwin_widget.c gwin_wm.c
    ../ugfx/src/ginput/: ginput_dial.c ginput_ginput.c ginput_keyboard.c ginput_mouse.c ginput_toggle.c
    ../ugfx/src/gadc/: gadc_gadc.c
    ../ugfx/src/gaudio/: gaudio_gaudio.c
    ../ugfx/src/gmisc/: gmisc_arrayops.c gmisc_gmisc.c gmisc_matrix2d.c gmisc_trig.c
    ../ugfx/src/gfile/: gfile_fatfs_wrapper.c gfile_fs_chibios.c gfile_fs_fatfs.c gfile_fs_mem.c gfile_fs_native.c gfile_fs_petitfs.c gfile_fs_ram.c gfile_fs_rom.c gfile_fs_strings.c gfile_gfile.c gfile_petitfs_diskio_chibios.c gfile_petitfs_wrapper.c gfile_printg.c gfile_scang.c gfile_stdio.c
    ../ugfx/drivers/gdisp/ILI9341/: gdisp_lld_ILI9341.c
